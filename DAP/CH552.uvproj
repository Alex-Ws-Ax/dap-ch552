# Keil uVision project CH552.uvproj, settings and files
target Target 1 (MCS-51)
  device: CH552 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF)  IROM(0-0x3FFF) CLOCK(24000000)
  output: CH552DEMO +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\DAP
  group Source Group 1
    ./: Debug.C DAP.c SW_DP.c Main_Usb.C
